#
# CIP Core, generic profile
#
# Copyright (c) Siemens AG, 2023
#
# SPDX-License-Identifier: MIT

require linux-cip-release.inc

SRC_URI[sha256sum] = "805490d21893c71af2fe8dcc4e45fa5a1c53619414894072390d6b3ad9fc79b6"
