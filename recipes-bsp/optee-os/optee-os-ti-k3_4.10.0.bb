#
# Copyright (c) Texas Instruments Incorporated, 2025
#
# Authors:
#  Sai Sree Kartheek Adivi <s-adivi@ti.com>
#
# SPDX-License-Identifier: MIT
#

inherit optee-os

require optee-os-ti-k3_${PV}.inc
require optee-os-ftpm-stmm.inc
