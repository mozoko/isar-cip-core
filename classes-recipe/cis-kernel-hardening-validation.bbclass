#
# CIP Core, generic profile
#
# Copyright (c) Siemens AG, 2026
#
# Authors:
#  Clara Kowalsky <clara.kowalsky@siemens.com>
#  Quirin Gylstorff <quirin.gylstorff@siemens.com>
#
# SPDX-License-Identifier: MIT
#
# Validate that the CIS hardening kernel config fragment generated by
# cip-cis-rules-config actually took effect in the kernel that was built, and
# write a JSON compliance report to DEPLOY_DIR_IMAGE.
#
DEPLOYDIR_HARDENING = "${WORKDIR}/deploy-hardening"

def cis_parse_fragment(lines):
    """Parse a CIS hardening kernel config fragment.

    Returns a list of rules, in file order:

        [{"name": "1.1.1.7",
          "description": "Disable FAT filesystems (FAT, MSDOS, VFAT)",
          "expectations": {"CONFIG_FAT_FS": "n", ...}}]

    A rule owns every config line following its "# CIS" header up to the next
    header.  Rules that carry no kernel symbol are dropped.  A repeated symbol
    within a rule, or a repeated "# CIS" id, resolves last-wins.

    "=m" is accepted for completeness; gen-kernel-config.py only ever emits
    "y" or "n" today.
    """
    import re

    rule_re = re.compile(r"^# CIS ([0-9.]+): (.*)$")
    disabled_re = re.compile(r"^# (CONFIG_[A-Za-z0-9_]+) is not set$")
    enabled_re = re.compile(r"^(CONFIG_[A-Za-z0-9_]+)=([ym])$")

    rules = []
    current = None

    for raw_line in lines:
        line = raw_line.strip()

        match = rule_re.match(line)
        if match:
            current = {
                "name": match.group(1),
                "description": match.group(2),
                "expectations": {},
            }
            rules.append(current)
            continue

        if current is None:
            continue

        match = disabled_re.match(line)
        if match:
            current["expectations"][match.group(1)] = "n"
            continue

        match = enabled_re.match(line)
        if match:
            current["expectations"][match.group(1)] = match.group(2)

    return [rule for rule in rules if rule["expectations"]]

def cis_parse_kernel_config(lines):
    """Parse a kernel configuration into a {symbol: value} dict.

    Symbols written as "# CONFIG_X is not set" are simply absent from the
    result, which is what cis_check_symbol expects.
    """
    import re

    config_set_re = re.compile(r"^(CONFIG_[A-Za-z0-9_]+)=(.*)$")

    options = {}

    for raw_line in lines:
        match = config_set_re.match(raw_line.strip())
        if match:
            options[match.group(1)] = match.group(2)

    return options

def cis_check_symbol(expected, actual):
    """Is a symbol's actual value acceptable for its expectation?

    An expectation of "n" is only met when the symbol is absent from the
    configuration: for a kernel we build ourselves, "=m" is as much a
    violation as "=y".
    """
    if expected == "n":
        return actual is None

    return actual == expected

def cis_evaluate(rules, options):
    """Check parsed rules against a parsed kernel configuration.

    Returns one entry per violating symbol, in rule order and, within a rule,
    sorted by symbol name:

        [{"rule": "1.1.1.5", "description": "...",
          "symbol": "CONFIG_SQUASHFS", "expected": "n", "actual": "y"}]
    """
    violations = []

    for rule in rules:
        for symbol in sorted(rule["expectations"]):
            expected = rule["expectations"][symbol]
            actual = options.get(symbol)

            if not cis_check_symbol(expected, actual):
                violations.append({
                    "rule": rule["name"],
                    "description": rule["description"],
                    "symbol": symbol,
                    "expected": expected,
                    "actual": "not set" if actual is None else actual,
                })

    return violations

def cis_build_report(rules, options):
    """Build the JSON compliance report for the checked rules."""
    report_rules = []

    for rule in rules:
        symbols = []

        for symbol in sorted(rule["expectations"]):
            expected = rule["expectations"][symbol]
            actual = options.get(symbol)

            symbols.append({
                "symbol": symbol,
                "expected": expected,
                "actual": "not set" if actual is None else actual,
                "compliant": cis_check_symbol(expected, actual),
            })

        report_rules.append({
            "rule": {
                "name": rule["name"],
                "description": rule["description"],
                "compliant": all(entry["compliant"] for entry in symbols),
                "symbols": symbols,
            }
        })

    return {"rules": report_rules}

def cis_format_violations(violations):
    """Render violations as an indented, one-per-line block for bb.fatal."""
    return "\n".join(
        "  CIS {rule} ({description}): {symbol} expected '{expected}', "
        "found '{actual}'".format(**violation)
        for violation in violations
    )

def cis_kernel_config_from_package(package):
    """Read the /boot/config-* file shipped inside a linux-image package."""
    import subprocess
    import tarfile

    try:
        unpack = subprocess.Popen(['dpkg-deb', '--fsys-tarfile', package],
                                  stdout=subprocess.PIPE)
        try:
            with tarfile.open(fileobj=unpack.stdout, mode='r|') as archive:
                for member in archive:
                    if member.name.startswith('./boot/config-'):
                        return archive.extractfile(member).read() \
                            .decode('utf-8').splitlines(True)
        finally:
            unpack.stdout.close()
            unpack.wait()
    except (OSError, tarfile.TarError) as error:
        bb.fatal("CIS kernel hardening validation: could not unpack %s: %s"
                 % (package, error))

    return None

SSTATETASKS += "do_validate_kernel_config"

do_validate_kernel_config[depends] += "cip-cis-rules-config:do_deploy_hardening"
do_validate_kernel_config[cleandirs] += "${DEPLOYDIR_HARDENING}"
do_validate_kernel_config[sstate-inputdirs] = "${DEPLOYDIR_HARDENING}"
do_validate_kernel_config[sstate-outputdirs] = "${DEPLOY_DIR_IMAGE}"

python do_validate_kernel_config() {
    import glob
    import json
    import os

    fragment_path = os.path.join(d.getVar('DEPLOY_DIR_IMAGE'),
                                 d.getVar('CIP_CIS_HARDENING_KCONFIG'))
    if not os.path.isfile(fragment_path):
        bb.fatal("CIS kernel hardening validation: %s not found."
                 % fragment_path)

    with open(fragment_path, 'r') as fragment_file:
        fragment_lines = fragment_file.readlines()

    rules = cis_parse_fragment(fragment_lines)
    if not rules:
        if any('CONFIG_' in line for line in fragment_lines):
            bb.fatal("CIS kernel hardening validation: %s contains CONFIG "
                     "symbols but no CIS rule could be parsed from it."
                     % fragment_path)
        bb.note("CIS kernel hardening validation: no kernel-relevant CIS "
                "rule selected, nothing to check.")
        return

    pattern = os.path.join(d.getVar('DEPLOYDIR'), 'linux-image-%s_*.deb'
                           % d.getVar('KERNEL_NAME_PROVIDED'))
    packages = glob.glob(pattern)
    if len(packages) != 1:
        bb.fatal("CIS kernel hardening validation: expected exactly one "
                 "kernel image package matching %s, found %d."
                 % (pattern, len(packages)))

    config_lines = cis_kernel_config_from_package(packages[0])
    if config_lines is None:
        bb.fatal("CIS kernel hardening validation: could not read a "
                 "/boot/config-* file from %s." % packages[0])

    options = cis_parse_kernel_config(config_lines)
    if not options:
        bb.fatal("CIS kernel hardening validation: the configuration in %s "
                 "contains no CONFIG symbols." % packages[0])

    report_path = os.path.join(d.getVar('DEPLOYDIR_HARDENING'),
                               d.getVar('CIP_CIS_HARDENING_REPORT'))
    with open(report_path, 'w') as report_file:
        json.dump(cis_build_report(rules, options), report_file, indent=2)

    bb.note("CIS kernel hardening validation: checked %d symbol(s) from "
            "%d rule(s) against %s"
            % (sum(len(rule["expectations"]) for rule in rules), len(rules),
               packages[0]))

    violations = cis_evaluate(rules, options)
    if violations:
        bb.fatal("CIS kernel hardening validation failed for %s:\n%s\n"
                 "Report: %s"
                 % (packages[0], cis_format_violations(violations),
                    report_path))
}

python do_validate_kernel_config_setscene () {
    sstate_setscene(d)
}
addtask validate_kernel_config_setscene

addtask validate_kernel_config after do_dpkg_build before do_deploy_deb
